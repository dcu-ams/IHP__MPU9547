v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {opin.sym} -200 -140 0 0 {name=p1 lab=A0}
C {opin.sym} -200 -120 0 0 {name=p2 lab=A1}
C {opin.sym} -200 -100 0 0 {name=p3 lab=A2}
C {opin.sym} -200 -80 0 0 {name=p4 lab=A3}
C {opin.sym} -200 -60 0 0 {name=p5 lab=A4}
C {opin.sym} -200 -40 0 0 {name=p6 lab=A5}
C {opin.sym} -200 -20 0 0 {name=p7 lab=A6}
C {opin.sym} -200 0 0 0 {name=p8 lab=A7}
C {opin.sym} -200 20 0 0 {name=p9 lab=A8}
C {opin.sym} -200 40 0 0 {name=p10 lab=A9}
C {iopin.sym} -400 -140 2 0 {name=p11 lab=D0}
C {iopin.sym} -400 -120 2 0 {name=p12 lab=D1}
C {iopin.sym} -400 -100 2 0 {name=p13 lab=D2}
C {iopin.sym} -400 -80 2 0 {name=p14 lab=D3}
C {iopin.sym} -400 -60 2 0 {name=p15 lab=D4}
C {iopin.sym} -400 -40 2 0 {name=p16 lab=D5}
C {iopin.sym} -400 -20 2 0 {name=p17 lab=D6}
C {iopin.sym} -400 0 2 0 {name=p18 lab=D7}
C {iopin.sym} -320 -200 3 0 {name=p19 lab=VDD3V3}
C {iopin.sym} -280 -200 3 0 {name=p20 lab=VDD1V2}
C {opin.sym} -200 80 0 0 {name=p23 lab=WR}
C {opin.sym} -200 100 0 0 {name=p24 lab=RD}
C {ipin.sym} -400 120 0 0 {name=p25 lab=RESET}
C {ipin.sym} -400 40 0 0 {name=p26 lab=CLK}
C {ipin.sym} -400 200 0 0 {name=p27 lab=EN}
C {opin.sym} -200 200 0 0 {name=p28 lab=OSC}
C {opin.sym} -200 120 0 0 {name=p29 lab=IORQ}
C {opin.sym} -200 140 0 0 {name=p30 lab=M1}
C {ipin.sym} -400 80 0 0 {name=p31 lab=INT}
C {opin.sym} -200 160 0 0 {name=p32 lab=MREQ}
C {iopin.sym} -300 240 1 0 {name=p21 lab=PGND}
